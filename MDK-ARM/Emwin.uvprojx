# Keil uVision project Emwin.uvprojx, settings and files
target Emwin (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TFTLCD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;       ../Drivers/STM32F1xx_HAL_Driver/Inc;       ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;       ../Drivers/CMSIS/Include;       ..\Drivers\LCD;       ..\Drivers\sys;       ..\Drivers\delay;       ..\Drivers\LED;       ..\Drivers\KEY;       ..\Drivers\24CXX;       ..\Drivers\TOUCH;       ..\Drivers\IIC;       ..\STemWin\Config;       ..\STemWin\inc;       ..\STemWin\Lib;       ..\STemWin\OS;       ..\Drivers\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/LCD
    ../Drivers/LCD/: ILI93xx.c
  group Drivers/sys
    ../Drivers/sys/: sys.c
  group Drivers/delay
    ../Drivers/delay/: delay.c
  group Drivers/TOUCH
    ../Drivers/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
  group Drivers/IIC
    ../Drivers/IIC/: myiic.c
  group Drivers/24CXX
    ../Drivers/24CXX/: 24cxx.c
  group Drivers/LED
    ../Drivers/LED/: led.c
  group Drivers/KEY
    ../Drivers/KEY/: key.c
  group STemwin
    ../STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUIConf.h GUI_X_Touch_Analog.c
    ../STemWin/OS/: GUI_X.c
    ../STemWin/Lib/: STemWin_CM3_wc16_ARGB.a
  group Drivers/MALLOC
    ../Drivers/MALLOC/: malloc.c
software components: CMSIS:CORE 4.3.0
